# Keil uVision project HID.uvprojx, settings and files
target STM32F103 Flash (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: HID
  c flags: Optim=4 OneElfS=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: HID.c USBD_User_HID_0.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, Board Support:MCBSTM32E:Graphic LCD 1.0.0, Board Support:MCBSTM32E:Joystick 1.0.0, Board Support:MCBSTM32E:LED 1.0.0, USB:CORE 5.0.5, USB:Device 5.0.5, USB:Device:HID 5.0.5, Device:GPIO 1.01.0, Device:Startup 1.0.0, Drivers:USB Device:Full-speed 1.0.0
