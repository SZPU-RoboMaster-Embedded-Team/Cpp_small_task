# Keil uVision project GUIDemo.uvprojx, settings and files
target MCBSTM32E (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: GUIDemo
  c flags: Optim=4
  c define: JOYSTICK_ROTATE
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32E LCD_LG (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: as above
  output: GUIDemo
  c flags: Optim=4
  c define: JOYSTICK_ROTATE
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, Board Support:MCBSTM32E:Joystick 1.0.0, Board Support:MCBSTM32E:emWin LCD 1.0.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Graphics:CORE 5.22.1, Graphics:Demo:Automotive 5.22.1, Graphics:Demo:Bitmap 5.22.1, Graphics:Demo:ColorBar 5.22.1, Graphics:Demo:Cursor 5.22.1, Graphics:Demo:Framework 5.22.1, Graphics:Demo:Graph 5.22.1, Graphics:Demo:ListView 5.22.1, Graphics:Demo:Speed 5.22.1, Graphics:Demo:TransparentDialog 5.22.1, Graphics:Demo:Treeview 5.22.1, Graphics:Display:MCBQVGA_LD 5.22.1, Graphics:Display:MCBQVGA_LG 5.22.1, Graphics:Input Device:Joystick 5.22.1
