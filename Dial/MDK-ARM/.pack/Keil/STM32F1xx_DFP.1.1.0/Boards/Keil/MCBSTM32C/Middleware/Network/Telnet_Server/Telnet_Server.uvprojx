# Keil uVision project Telnet_Server.uvprojx, settings and files
target STM32F107 Flash (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Telnet_Server
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: Telnet_Server.c Telnet_Server_UIF.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, Board Support:MCBSTM32C:A/D Converter 1.0.0, Board Support:MCBSTM32C:Graphic LCD 1.0.0, Board Support:MCBSTM32C:LED 1.0.0, Network:CORE 5.0.4, Network:Interface:ETH 5.0.4, Network:Service:Telnet Server 5.0.4, Network:Socket:TCP 5.0.4, Network:Socket:UDP 5.0.4, Device:GPIO 1.01.0, Device:Startup 1.0.0, Drivers:Ethernet MAC 1.02.0, Drivers:Ethernet PHY:DP83848C 5.01.0
