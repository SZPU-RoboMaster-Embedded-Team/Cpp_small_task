# Keil uVision project Keyboard.uvprojx, settings and files
target STM32107 Flash (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Keyboard
  c flags: Optim=4 OneElfS=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: Keyboard.c Mcommand.c Getline.c Retarget.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, Board Support:MCBSTM32C:A/D Converter 1.0.0, Board Support:MCBSTM32C:Graphic LCD 1.0.0, USB:CORE 5.0.5, USB:Host 5.0.5, USB:Host:HID 5.0.5, Device:GPIO 1.01.0, Device:Startup 1.0.0, Drivers:USB Host 1.0.0
