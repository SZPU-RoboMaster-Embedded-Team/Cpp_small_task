# Keil uVision project Demo.uvprojx, settings and files
target STM32F107 Flash (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Demo
  c flags: Optim=4
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Files
    ./: Demo.c Arrows_16bpp_red.c Bulb_16bpp.c Button_16bpp.c
  group Documentation
    ./: Abstract.txt
target STM32F107 MDK-Lite (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: as above
  output: Demo
  c flags: Optim=1
  c define: _EVAL_VERSION_
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, Board Support:MCBSTM32C:A/D Converter 1.0.0, Board Support:MCBSTM32C:Graphic LCD 1.0.0, Board Support:MCBSTM32C:Joystick 1.0.0, Board Support:MCBSTM32C:Keyboard 1.0.0, Board Support:MCBSTM32C:LED 1.0.0, Board Support:MCBSTM32C:Touchscreen 1.0.0, Device:DMA 1.01.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Drivers:I2C 1.01.0
