# Keil uVision project GUIDemo.uvprojx, settings and files
target MCBSTM32C (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: GUIDemo
  c flags: Optim=4
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32C LCD_LG (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: as above
  output: GUIDemo
  c flags: Optim=4
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, Board Support:MCBSTM32C:Joystick 1.0.0, Board Support:MCBSTM32C:Touchscreen 1.0.0, Board Support:MCBSTM32C:emWin LCD 1.0.0, Device:DMA 1.01.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Drivers:I2C 1.01.0, Drivers:SPI 1.03.0, Graphics:CORE 5.22.1, Graphics:Demo:Automotive 5.22.1, Graphics:Demo:Bitmap 5.22.1, Graphics:Demo:ColorBar 5.22.1, Graphics:Demo:Cursor 5.22.1, Graphics:Demo:Framework 5.22.1, Graphics:Demo:Graph 5.22.1, Graphics:Demo:ListView 5.22.1, Graphics:Demo:Speed 5.22.1, Graphics:Demo:TransparentDialog 5.22.1, Graphics:Display:MCBQVGA_LD 5.22.1, Graphics:Display:MCBQVGA_LG 5.22.1, Graphics:Input Device:Joystick 5.22.1, Graphics:Input Device:Touchscreen 5.22.1
