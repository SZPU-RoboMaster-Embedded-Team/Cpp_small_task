# Keil uVision project FTP_Server.uvprojx, settings and files
target STM32F107 Flash (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: FTP_Server
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: FTP_Server.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, Board Support:MCBSTM32C:Graphic LCD 1.0.0, Board Support:MCBSTM32C:LED 1.0.0, File System:CORE 5.0.5, File System:Drive:Memory Card 5.0.5, Network:CORE 5.0.4, Network:Interface:ETH 5.0.4, Network:Service:FTP Server 5.0.4, Network:Socket:TCP 5.0.4, Network:Socket:UDP 5.0.4, Device:DMA 1.01.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Drivers:Ethernet MAC 1.02.0, Drivers:Ethernet PHY:DP83848C 5.01.0, Drivers:MCI 1.01.0, Drivers:SPI 1.03.0
