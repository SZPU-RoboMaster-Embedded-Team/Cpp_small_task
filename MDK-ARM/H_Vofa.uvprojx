# Keil uVision project H_Vofa.uvprojx, settings and files
target H_Vofa (6140001::V6.14.1::ARMCLANG)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: H_Vofa +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=9 wLevel=3
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\User
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group BSP
    ../User/BSP/CAN/: Bsp_Can.cpp Bsp_Can.hpp
    ../User/BSP/CRC/: crc.cpp crc.hpp
    ../User/BSP/Motor/Dji/: DjiMotor.hpp
    ../User/BSP/Motor/DM/: DmMotor.hpp DmTypes.hpp
    ../User/BSP/Motor/: MotorBase.hpp
    ../User/BSP/Remote/Dbus/: Dbus.cpp Dbus.hpp
    ../User/BSP/Remote/Mini/: Mini.cpp Mini.hpp
    ../User/BSP/Remote/: Key.hpp
    ../User/BSP/: Init.cpp Init.hpp StaticTime.hpp stdxxx.hpp
    ../User/BSP/Vofa/: Vofa_send.hpp
  group Algorithm
    ../User/Algorithm/: pid.cpp pid.hpp
  group APP
    ../User/APP/: variables.cpp variables.hpp
  group Task
    ../User/Task/: call_back.cpp call_back.hpp
software components: CMSIS:CORE 5.4.0
